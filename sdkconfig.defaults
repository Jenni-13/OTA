## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="MEGACABLE-4D9F"
CONFIG_EXAMPLE_WIFI_PASSWORD="t2dhtfXE"
CONFIG_BROKER_URI="mqtts://l46d1e5e.ala.us-east-1.emqxsl.com:8883"
```
